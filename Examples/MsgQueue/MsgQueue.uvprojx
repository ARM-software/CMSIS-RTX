# Keil uVision project MsgQueue.uvprojx, settings and files
target Simulator (6190000::V6.19::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MsqQueue
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDOUT:Event Recorder 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.7.0, Device:Startup 2.2.0
