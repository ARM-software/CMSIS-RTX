# Keil uVision project MsqQueue.uvprojx, settings and files
target Simulator (6190000::V6.19::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MsqQueue
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group Source Group 1
    ./: main.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS-Compiler:I/O:STDOUT 1.0.1, CMSIS-Compiler:OS Interface:CMSIS-RTOS2 1.1.0, CMSIS-View:Event Recorder 1.5.2, CMSIS:CORE 5.7.0, CMSIS:RTOS2:Keil RTX5 5.7.0, Device:OS Tick:SysTick 1.0.0, Device:Startup 2.0.3
